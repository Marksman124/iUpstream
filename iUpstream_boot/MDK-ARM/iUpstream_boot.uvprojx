# Keil uVision project iUpstream_boot.uvprojx, settings and files
target iUpstream_boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: iUpstream_boot +hex
  AfterMake: fromelf --bin --output=.\Output\iUpstream_boot.bin .\iUpstream_boot\iUpstream_boot.axf
  AfterMake: fromelf --bin --output=..\..\iUpstream_app\Bin\iUpstream_boot.bin .\iUpstream_boot\iUpstream_boot.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../STM32MB/modbus/rtu;../STM32MB/port;../STM32MB/modbus/include;../STM32MB/modbus/ascii;../STM32MB/modbus/tcp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: iap.c stmflash.c sys.c main.c gpio.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Modbus
    ../STM32MB/modbus/rtu/: mbcrc.c
software components: CMSIS:CORE 4.3.0
